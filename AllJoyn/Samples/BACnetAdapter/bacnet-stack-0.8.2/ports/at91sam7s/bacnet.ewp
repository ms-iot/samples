# IAR project bacnet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BACDL_MSTP; MAX_TSM_TRANSACTIONS=0; MAX_CHARACTER_STRING_BYTES=64; MAX_OCTET_STRING_BYTES=64; PRINT_ENABLED=0; MAX_APDU=480; CRC_USE_TABLE
  ICCARM.CCIncludePath2: ..\..\include; ..\..\demo\object; ..\..\demo\handler
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bacnet.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ai.c av.c bi.c blinker.c bv.c device.c dlmstp.c init.c isr.c main.c rs485.c timer.c
  group BACnet-Core
    ../../src/: abort.c apdu.c bacaddr.c bacapp.c bacdcode.c bacdevobjpropref.c bacerror.c bacint.c bacreal.c bacstr.c crc.c datetime.c dcc.c iam.c ihave.c lighting.c memcopy.c npdu.c proplist.c rd.c reject.c ringbuf.c rp.c rpm.c version.c whohas.c whois.c wp.c
  group BACnet-Demo
    ../../demo/handler/: h_dcc.c h_npdu.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c noserv.c s_iam.c s_ihave.c txbuf.c
