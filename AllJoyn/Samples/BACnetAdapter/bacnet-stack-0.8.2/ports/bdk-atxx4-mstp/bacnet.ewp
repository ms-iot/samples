# IAR project bacnet.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x400
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1284p ATmega1284P
  ICCAVR.CCDefines: BACDL_MSTP; MAX_ANALOG_INPUTS=100; MAX_APDU=50; BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=0; MSTP_PDU_PACKET_COUNT=2; MAX_CHARACTER_STRING_BYTES=64; MAX_OCTET_STRING_BYTES=64; BACAPP_BOOLEAN; BACAPP_REAL; BACAPP_OBJECT_ID; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING; WRITE_PROPERTY
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; ..\..\include; ..\..\demo\object
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1284p.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BACDL_MSTP; MAX_APDU=128; BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=0; MSTP_PDU_PACKET_COUNT=2; MAX_CHARACTER_STRING_BYTES=64; MAX_OCTET_STRING_BYTES=64; BACAPP_BOOLEAN; BACAPP_REAL; BACAPP_OBJECT_ID; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING; WRITE_PROPERTY
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm644p.xcl
  group (top)
    ./: adc.c ai.c av.c bacnet.c bi.c bname.c bo.c device.c dlmstp.c eeprom.c fuses.c init.c input.c led.c main.c rs485.c seeprom.c serial.c stack.c test.c timer.c timer2.c watchdog.c
  group BACnet-Core
    ../../src/: abort.c apdu.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c dcc.c fifo.c iam.c ihave.c memcopy.c npdu.c rd.c reject.c ringbuf.c rp.c rpm.c whohas.c whois.c wp.c
  group BACnet-Demo
    ../../demo/handler/: h_dcc.c h_npdu.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c noserv.c s_iam.c s_ihave.c txbuf.c
